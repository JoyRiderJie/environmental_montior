# Keil uVision project smart_enviromental.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: smart_enviromental +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\c8t6Project;..\..\App\inc;..\..\Sensor\inc;..\..\FreeRTOS_Source\include;..\..\FreeRTOS_Source\portable\MemMang;..\..\FreeRTOS_Source\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App/module
    ../../App/src/: delay.c iic.c led.c lora_app.c lora_ui.c sys.c time.c usart.c
  group App/config
    ./: main.c config.c stm32f10x_it.c
  group FreeRTOS/module
    ../../FreeRTOS_Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../FreeRTOS_Source/portable/MemMang/: heap_4.c
    ../../FreeRTOS_Source/portable/RVDS/ARM_CM3/: port.c
  group Sensor
    ../../Sensor/src/: bh1750.c dht11.c MQ2.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.6.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:RTC 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
