# Keil uVision project zet6.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: zet6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\zet6Project;..\..\App\inc;..\..\FreeRTOS_Source\include;..\..\FreeRTOS_Source\portable\MemMang;..\..\FreeRTOS_Source\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App/Module
    ../../App/src/: delay.c led.c lora_app.c lora_ui.c sys.c time.c usart.c Oled.c app_cloud.c HAL_WiFiToCloud.c iic.c WiFiToCloud.c
  group App/Config
    ./: config.c main.c stm32f10x_it.c
  group FreeRTOS
    ../../FreeRTOS_Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../FreeRTOS_Source/portable/RVDS/ARM_CM3/: port.c
    ../../FreeRTOS_Source/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DBGMCU 3.6.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
